DESCRIPTION = ""

require recipes-core/images/core-image-minimal.bb
